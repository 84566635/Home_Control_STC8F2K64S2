# Keil uVision project Laite_Dimmer_.uvproj, settings and files
target Laite_Dimmer (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: Laite_Dimmer +hex
  c flags: Optimize=8 SizeSpeed=1
  group Laite_Dimmer
    ../User/: main.c MyConfig.h io.c io.h relay.c relay.h rs485.c rs485.h crc8.c crc8.h delay.c delay.h watchdog.c watchdog.h
